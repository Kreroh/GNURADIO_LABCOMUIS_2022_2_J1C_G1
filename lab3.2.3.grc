options:
  parameters:
    author: Yanez_Vega
    generate_options: qt_gui
    id: TransmisorAM_J1C_01
    output_language: python
    title: TransmisorAM_J1C_01
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud modulante
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '0.0001'
    stop: '4'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del Mensaje
    start: '1000'
    step: '1000'
    stop: '10000'
    value: '5000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    i_vect: '1024'
  states: {}
- name: SSB_0
  id: SSB
  parameters:
    Ac: Ac
    B: '1'
    K: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '50000000'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [SSB_0, '0', blocks_complex_to_float_0, '0']
- [SSB_0, '0', blocks_complex_to_mag_0, '0']
- [SSB_0, '0', qtgui_freq_sink_x_0, '0']
- [SSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotenciaComunicaciones_0, '0']
- [analog_sig_source_x_0, '0', SSB_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
